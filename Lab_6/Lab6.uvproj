# Keil uVision project Lab6.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS89C420 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(50000000) MODDP2
  output: Lab6 +hex
  c flags: Optimize=5
  group Lab6
    ./: Lab6.c
